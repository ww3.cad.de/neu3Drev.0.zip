# Autodesk Inventor part: neu Shark
## iProperties
Created: 2010-08
Part Number: neu Shark
Document SubType Name: Modeling
Designer: MK
Density: 1 g/cm^3
Author: MK
## Feature names
1. Erhebung1
